# Keil uVision project silverware.uvprojx, settings and files
target BWhoop (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bwhoop +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F031
  c misc: --fpmode=fast
  c include: .\src;..\;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Utilities\;.\hard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c buzzer.c flash.c rx_bayang_protocol_ble.c rx_sbus.c led.c rgb_led.c sixaxis.c motorcurve.c util.c stickvector.c imu.c flip_sequencer.c filter.cpp defines.h hardware.h config.h debug.h drv_softserial.c serial_4way.c serial_4way_stk500v2.c serial_4way_avrootloader.c
  group drv
    ./src/: drv_adc.c drv_clk.c drv_fmc1.c drv_fmc2.c drv_gpio.c drv_i2c.c drv_pwm.c drv_esc.c drv_serial.c drv_softi2c.c drv_spi_3wire.c drv_time.c drv_xn297_3wire.c drv_hw_i2c.c drv_rgb.c drv_osd.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f031.s
  group Peripherals
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group SystemInit
    ../Utilities/: system_stm32f0xx.c
  group hard
    ./hard/: timer.c motor_control.c
